Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Wash-basins_Ceramica-Catalano_ALVEA-lavabo-120x46-2-sinks-cod-06212220.ifc
Time: 2023-10-26T14:42:45
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: ALVEA lavabo 120x46 2 sinks cod. 0621222001
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): ALVEA lavabo 120x46 2 sinks cod. 0621222001; SKU (BO_prodsku): lavabo-alvea-120x46-2-sinks-cod-0621222001; ManufacturName (BO_Manufac): Ceramica Catalano; BrandUrl (BO_brandurl): http://www.catalano.it/; ProductFamily (BO_prodfam): Alvea; ProductGroup (BO_prodgroup): Basin; EditionNumber (BO_edinum): 1; Width (BO_width): 1200; Height (BO_height): 180; Depth (BO_depth): 460; Weight (BO_weight): 20; QR (BO_boqrurl): http://bimobject.com/ceramica-catalano/product/lavabo-alvea-120x46-2-sinks-cod-0621222001; ProductDataUrl (BO_prodaturl): bimobject.com/ceramica-catalano/product/lavabo-alvea-120x46-2-sinks-cod-0621222001; MaterialMain (BO_mainmat): Ceramics; MaterialSecondary (BO_secmat): Fireclay; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Wash basins; BimObjectCategoryCode (BO_bocat_code): wash-basins; IfcClassification (BO_ifcclas): Sanitary Terminal; Uniclass2015Code (BO_uniclass2015_code): Pr_40_20_96_15; Uniclass2015Description (BO_uniclass2015_desc): Ceramic sinks; OmniClassCode (BO_omniclass_code): 23-31 13 00; OmniClassDescription (BO_omniclass_name): Sinks; MasterFormat2014Code (BO_masterformat2014_code): 22 41 16.16; MasterFormat2014Description (BO_masterformat2014_name): Residential Sinks; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
